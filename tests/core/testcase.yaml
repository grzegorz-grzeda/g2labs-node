## tests/core/testcase.yaml
```yaml
common:
  tags: node_core
  platform_allow:
    - native_sim
  integration_platforms:
    - native_sim
tests:
  node.core: {}
```
